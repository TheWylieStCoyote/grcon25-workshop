options:
  parameters:
    author: wylie
    generate_options: qt_gui
    id: signal_source_complex
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Amplitude
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency (Hz)
    start: '-samp_rate'
    step: '100'
    stop: samp_rate
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    comment: Sine wave generator
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
