options:
  parameters:
    author: Workshop
    comment: RTL-SDR spectrum analyzer
    description: Simple spectrum analyzer using RTL-SDR
    generate_options: qt_gui
    id: rtlsdr_spectrum
    output_language: python
    title: RTL-SDR Spectrum Analyzer
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center Frequency (MHz)
    start: '88'
    step: '0.1'
    stop: '108'
    value: '100'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Note: Requires gr-osmosdr'
    imports: import osmosdr
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    comment: RTL-SDR Source
    freq0: center_freq*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'Alternative: File source for testing'
    file: /dev/urandom
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Use with file source
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq*1e6
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,3,3
    legend: 'False'
    name: '"Spectrum Analyzer"'
    type: complex
    ymin: '-110'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq*1e6
    fftsize: '2048'
    gui_hint: 5,0,3,3
    int_min: '-110'
    legend: 'False'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      To use RTL-SDR:
      1. Enable osmosdr_source
      2. Disable file_source and throttle
      3. Connect osmosdr to sinks
    note: RTL-SDR Hardware Note
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
